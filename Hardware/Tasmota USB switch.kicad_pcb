# Repository cdntinker/Tasmota-Micro

File README.md:

# Tasmota-Micro
It's NOT a Sonoff Micro

So, I received my shiny new Sonoff Micro in the mail today...

It works...

As far as it goes.

They tried to make a useful device and failed.

The Micro does switch the power to a USB device via WiFi control.  That's pretty much all it does.

What it does not do is pass the data lines through.  This is dumb.

It also uses a new microprocessor that may or may not be hackable.  It's also glued shut.  It's Bloody bulky as well.  These are annoying things.

So, I've spent a couple hours tinkering...

The initial commit here is very much a FUGLY proof of concept.  I plan to refine it a whole bunch as time & energy permit.

## KiCad design Hardware/Tasmota USB switch.kicad_pcb

Parts:
C1, C2: C; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_A; USB_A_CNCTech_1001-011-01101_Horizontal
J2: USB_A; USB3_A_Molex_48393-001
J3: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
Q1: 2N7000; TO-92_Inline
R1: R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
U1: ESP-01v090; ESP-01
U2: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
GND: C1.2, C2.2, J1.4 (GND), J1.5 (Shield), J2.5 (Shield), J2.10, J3.4, Q1.1 (S), SW1.2, U1.2, U2.1 (GND)
unnamed: C2.1, J3.1, U1.3, U1.7, U2.2 (VO)
unnamed: D1.1 (K), R1.1
unnamed: J1.2 (D-), J2.2 (D-)
unnamed: J1.3 (D+), J2.3 (D+)
unnamed: J2.4 (GND), Q1.3 (D), R1.2
unnamed: J3.2, U1.8
unnamed: J3.3, U1.1
unnamed: J3.5, U1.5
unnamed: J3.6, SW1.1, U1.6
unnamed: Q1.2 (G), U1.4
VBUS: C1.1, D1.2 (A), J1.1 (VBUS), J2.1 (VBUS), U2.3 (VI)

Board: 2 copper layers, 58.4 x 27.9 mm, 11 parts (0 on the bottom side), 12 nets.

## Commit log

2020-02-04 Add files via upload
    Yes...
    This initial version is the very definition of FUGLY!
    But the circuit works as a breadboard version made of salvaged parts.
    It'll get better...
2020-02-04 Add files via upload
    Revision 0.0.1
2020-02-05 V0.0.2
    Now with the missing Voltage regulator!!!
2020-02-05 Add files via upload
    v0.0.2
2020-02-08 v0.0.3
    Now with blinkenlight
2022-03-02 Converting to new format of repo
2022-03-03 Finally... A seemingly good .gitignore.
